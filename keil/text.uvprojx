# Keil uVision project text.uvprojx, settings and files
target empty_LP_MSPM0G3519_nortos_keil (6240000::V6.24::ARMCLANG)
  device: MSPM0G3519 Texas Instruments
  pack: TexasInstruments.MSPM0GX51X_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x20100000,0x00010000) IROM(0x00000000,0x00080000) IROM2(0x00400000,0x00080000) XRAM(0x20200000,0x00020000) XRAM2(0x20300000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: test +hex
  BeforeMake: C:\ti\mspm0_sdk_2_08_00_03\tools\keil\syscfg.bat
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __MSPM0G3519__
  c include: ../;../../../../../../source/third_party/CMSIS/Core/Include;../../../../../../source;..\..\..\source\third_party\CMSIS\Core\Include;..\..\..\source;.\Hardware;..\ti\eeprom;..\ti\eeprom\emulation_type_a;D:\Desktop\STM32 Project\3-5 旋转编码器\CMSIS
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x80000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x20300000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20100000 size 0x10000
  scatter file: .\mspm0g3519.sct
  link misc: C:\ti\mspm0_sdk_2_08_00_03\source\ti\driverlib\lib\keil\m0p\mspm0gx51x\driverlib.a
  group Source
    ./: startup_mspm0g351x_uvision.s
    ../: ti_msp_dl_config.h ti_msp_dl_config.c main.c project.syscfg
    ../ti/eeprom/emulation_type_a/: eeprom_emulation_type_a.c eeprom_emulation_type_a.h
    ../ti/eeprom/emulation_type_b/: eeprom_emulation_type_b.c eeprom_emulation_type_b.h
  group Hardware
    ./Hardware/: bsp.h Keyboard.c Keyboard.h LED.c LED.h oled_spi_V0.2.c oled_spi_V0.2.h oledfont.h oledpicture_V0.2.h MusicPlayer.c MusicPlayer.h MusicScore.h
